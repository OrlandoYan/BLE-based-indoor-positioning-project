# IAR project SampleAppThT.ewp, settings and files
configuration SampleApp_SERVER (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401RE ST STM32F401RE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F401xE; USE_STM32F4XX_NUCLEO; USE_HAL_DRIVER; SERVER_ROLE
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_BlueNRG\SimpleBlueNRG_HCI\includes; ..\..\..\..\..\..\Middlewares\ST\STM32_BlueNRG\Interface; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32F4xx-Nucleo; ..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-IDB0xA1
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SampleApp_SERVER_F401RE.bin
  ILINK.IlinkOutputFile: SampleApp_SERVER.out
  ILINK.IlinkIcfFile: stm32f401xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration SampleApp_CLIENT (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F401xE ST STM32F401xE
  ICCARM.CCDefines: STM32F401xE; USE_STM32F4XX_NUCLEO; USE_HAL_DRIVER; CLIENT_ROLE
  OBJCOPY.OOCOutputFile: SampleApp_CLIENT_F401RE.bin
  ILINK.IlinkOutputFile: SampleApp_CLIENT.out
configuration ThroughputTest_SERVER (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F401xE ST STM32F401xE
  ICCARM.CCDefines: STM32F401xE; USE_STM32F4XX_NUCLEO; USE_HAL_DRIVER; SERVER_ROLE; THROUGHPUT_TEST; OPTIMIZED_SPI
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: ThroughputTest_SERVER_F401RE.bin
  ILINK.IlinkOutputFile: ThroughputTest_SERVER.out
configuration ThroughputTest_CLIENT (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F401xE ST STM32F401xE
  ICCARM.CCDefines: STM32F401xE; USE_STM32F4XX_NUCLEO; USE_HAL_DRIVER; CLIENT_ROLE; THROUGHPUT_TEST
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: ThroughputTest_CLIENT_F401RE.bin
  ILINK.IlinkOutputFile: ThroughputTest_CLIENT.out
  group Application/EWARM
    ./: startup_stm32f401xe.s
  group Application/User
    ../../Src/: bluenrg_interface.c cube_hal_f4.c main.c sample_service.c stm32f4xx_hal_msp.c stm32xx_it.c uart_support.c
  group Doc
    ../../: readme.txt
  group Drivers/BSP/STM32F4xx_NUCLEO
    ../../../../../../Drivers/BSP/STM32F4xx-Nucleo/: stm32f4xx_nucleo.c
  group Drivers/BSP/X-NUCLEO-IDB0xA1
    ../../../../../../Drivers/BSP/X-NUCLEO-IDB0xA1/: stm32_bluenrg_ble.c
  group Drivers/CMSIS
    ../../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Middlewares/STM32_BlueNRG/HCI
    ../../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/hci/: hci.c hci_le.c
  group Middlewares/STM32_BlueNRG/HCI/controller
    ../../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/hci/controller/: bluenrg_gap_aci.c bluenrg_gatt_aci.c bluenrg_hal_aci.c bluenrg_l2cap_aci.c bluenrg_utils_small.c
  group Middlewares/STM32_BlueNRG/Interface
    ../../../../../../Middlewares/ST/STM32_BlueNRG/Interface/: bluenrg_itf.c
  group Middlewares/STM32_BlueNRG/Utils
    ../../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/utils/: ble_list.c gp_timer.c osal.c
